# Keil uVision project Key_Borat_Pro.uvprojx, settings and files
target Key_Board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EXI1800_Unit8_Key_Board_U9_T2_0 +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\App;..\..\Bsp;..\..\User;..\..\uCOS-III\Source;..\..\uCOS-III\Ports;..\..\uCOS-III\uC-CPU;..\..\uCOS-III\Cfg;..\..\uCOS-III\uC-LIB;..\..\User\CONFIG;..\..\HARDWARE;..\..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Mid
    ../../User/MID/: Mid.c Mid_op.c Mid_ReBack.c
  group System
    ../../SYSTEM/CTRLCAN/: CtrlCan.c
    ../../SYSTEM/CTRLCOM/: CtrlCom.c
    ../../SYSTEM/CTRLDMA/: CtrlDma.c
    ../../SYSTEM/CTRLSPI/: CtrlSpi.c
    ../../SYSTEM/QUEUE/: queue.c
    ../../SYSTEM/STM_SYS/: Stm_Sys.c
    ../../SYSTEM/SYS_DELAY/: Sys_Delay.c
    ../../SYSTEM/STMFLASH/: stmflash.c
  group Hardware
    ../../HARDWARE/LED/: led.c
    ../../HARDWARE/LOAD_PARAMETER/: Load_Parameter.c
    ../../HARDWARE/MT_CTRL/: ConfigMtx.c Motor.c Mtx.c Mtx_CtrlPin.c Mtx_LightPin.c MTx_Timer.c
    ../../HARDWARE/OUT_FLASH/: FM25CL64.c
    ../../HARDWARE/ENTER_CUP/: EnterCupMt.c
    ../../HARDWARE/LED_KEY_CTRL/: Led_key_ctrl.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uC\Source
    ../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC\Ports
    ../../uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uC\Lib
    ../../uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_cfg.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC\Cpu
    ../../uCOS-III/uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cfg.h cpu_core.c cpu_core.h cpu_def.h
  group uC\Cfg
    ../../uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h os_cfg_app.h os_cfg.h
software components: CMSIS:CORE 4.3.0
